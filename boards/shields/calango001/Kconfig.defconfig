## boards/shields/calango001/Kconfig.defconfig
```kconfig
if SHIELD_CALANGO001

config ZMK_KEYBOARD_NAME
    default "calangoPlanck"

endif # SHIELD_CALANGO001
```
